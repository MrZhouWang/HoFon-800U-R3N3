# Keil uVision project 800U-P3N3-T3N3 IO.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: 800U P3N3 IO_V2_1(RYN)_20151218 +hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ../src/: main.c CBM7008.C
