# Keil uVision project 800U-RXN3.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F300 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(25000000)
  output: 800U-RXN3 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\INC;..\PRO;..\SRC
  group Source Group 1
    ./: STARTUP.A51
  group INC
    ../INC/: C8051F300.H include.h timer.h adc.h led.h main.h delay.h init.h exti.h key.h
  group SRC
    ../SRC/: timer.c adc.c led.c main.c delay.c init.c exti.c key.c
  group 调试笔记
    ./: 调试笔记.txt
