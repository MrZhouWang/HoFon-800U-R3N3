# Keil uVision project 800U-R3N3.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F300 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(25000000)
  output: 800U-R3N3 +hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ./Source File/: STARTUP.A51 800U-R3N3.c
